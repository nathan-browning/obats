options:
  parameters:
    author: obats
    generate_options: qt_gui
    id: udp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/obats/Software/ReadGPS/out.txt
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '12'
    port: '5005'
    src_zeros: 'True'
    type: byte
  states: {}

connections:
- [network_udp_source_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1
