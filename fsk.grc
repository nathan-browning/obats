options:
  parameters:
    author: OBATS team
    description: FSK_Example
    generate_options: no_gui
    id: fsk_example
    output_language: python
    title: FSK_Example
  states: {}

blocks:
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '128177'
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-70'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '.850'
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/obats/Software/ReadGPS/out.txt
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/obats/Documents/source.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.068'
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1056'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '.500'
    samp_rate: '48000'
    sensitivity: '15708'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: '48000'
    sensitivity: '15708'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0, 0)
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import serial
      import time
      from datetime import datetime


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.complex]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, output_items):
              """example: multiply with constant"""
              output_items[0][:] = self.example_param
              
              return [1,1,1,1,1,1,1,1]
          # open file to potentially write input to
          f1 = open("input.txt", "w")
          
          # find and connect to serial port connected to GPS
          gps = serial.Serial('../../../../dev/ttyACM0', baudrate = 9600, timeout = 0.5)      # ../../dev/ttyACM0 from home folder (type cd in command line)
          string = gps.readline()                                                             # read data from serial port

          print("DATA FORMAT:")
          print("CPU time, GPS time, latitude(latitude direction), longitude(longitude direction), speed, CPU date, GPS date")
          print("\n")
          print("START DATA:")

          while 1:
              data = gps.readline()
              parseGPS(data)
              
              
              
              # convert the data in the NMEA message into a easy-to-read format
      def parseGPS(data):
          data_str = str(data)                                    # convert data to a string
          key1 = "$GNRMC"                                         # GP signifies a satellite from the US network
          key2 = "$GPRMC"                                         # GN signifies a satellite from the Russian network

          if data_str.find(key1) > 0 or data_str.find(key2) > 0:  # find right NMEA message
              sdata = data_str.split(",")                         # parse
              if sdata[2] == 'V':
                  print("NO SATELLITE DATA AVAILABLE")
                  return
              
              # parse the RMC message
              time = sdata[1][0:2] + ":" + sdata[1][2:4] + ":" + sdata[1][4:6]    # time
              lat = decode(sdata[3])                                              # latitude
              dirLat = sdata[4]                                                   # N/S
              lon = decode(sdata[5])                                              # longitude
              dirLon = sdata[6]                                                   # E/W
              speed = sdata[7]                                                    # speed in knots
              trCourse = sdata[8]                                                 # True Course (DON'T NEED)
              date = sdata[9][0:2] + "/" + sdata[9][2:4] + "/" + sdata[9][4:6]    # date
              
              # get the curretnt time and date from microcontroller
              # note: there is a consistent five hour difference between CPU and GPS
              curTime = str(datetime.now())
              scurTime = curTime.split(" ")
              cpuTime = scurTime[1][0:8]                                                              # formatting CPU time to match GPS time
              cpuDate = scurTime[0][8:10] + "/" + scurTime[0][5:7] + "/" + scurTime[0][2:4]           # formatting CPU date to match GPS date

              # display all the data
              print(cpuTime + "," + time + "," + lat + "(" + dirLat + ")," + lon + "(" + dirLon + ")," + speed + "," + cpuDate + "," + date)

      def decode(coord):
          # converts DDMM.MMMMM > DD deg MM.MMMMM
          x = coord.split(".")
          head = x[0]
          tail = x[1]
          deg = head[0:-2]
          minimum = head[-2:]
          return deg + " deg " + minimum + "." + tail + " min"

      # write data to file
      def readDataToFile(user_input):
          # open file in read-only mode
          f1 = open("input.txt", "r")

          content = f1.read()                         # get data from file
          split_content = content.split()             # split data from file into lines

          counter = 0

          # count the number of lines
          for i in split_content:
              if i:
                  counter += 1

          print("the number of lines in the file:")
          print(counter)

          f1.close()
          
          # if there is 100 lines already, clear file, and start at top. Otherwise, append
          if counter >= 100:
              f1 = open("input.txt", "w")             # open in write mode (overwrites current data in file)
          else:
              f1 = open("input.txt", "a")             # open in append mode (adds data at end of file)

          f1.write(user_input)                        # write data
          f1.write("\n")                              # add newline

          f1.close()

      # calling the main function
      if __name__ == "__main__":
          work()
    example_param: '1.0'
  states: {state: disabled}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '2210'
    decim: '1'
    samp_rate: '48000'
    taps: firdes.low_pass(1.0,48000,1000,400)
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '81'
    port: '5005'
    src_zeros: 'False'
    type: byte
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: TX1
    bb_gain0: '80'
    bw0: '5000'
    freq0: 2.4e9
    gain0: '80'
    if_gain0: '80'
    sample_rate: 1e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1000'
    srate: '48000'
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: xmt_data
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fsk_out
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: xmt_data
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fsk_out
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_c_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_1, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_throttle_0, '0']
- [blocks_vco_c_0, '0', osmosdr_sink_0, '0']
- [blocks_vco_c_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vco_c_0, '0', virtual_sink_1, '0']
- [blocks_vco_f_0, '0', blocks_file_sink_1, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', blocks_vco_c_0, '0']
- [low_pass_filter_0, '0', blocks_vco_f_0, '0']
- [network_udp_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
